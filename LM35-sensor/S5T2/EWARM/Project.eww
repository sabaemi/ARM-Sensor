<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\S5T2.ewp</path>
  </project>
  <batchBuild />
</workspace>
